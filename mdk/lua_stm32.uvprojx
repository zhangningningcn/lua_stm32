# Keil uVision project lua_stm32.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lua_stm32
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4XX USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ..\spiffs;..\Lib\STM32F4xx\inc;..\Lib\CMSIS\CM4;..\modules\cm4;..\app;..\Lib\VCP\inc;..\lua
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../app/: app_misc.c app_usart.c io.c main.c rtc.c stm32f4xx_it.c system_stm32f4xx.c
  group Libstd
    ../Lib/STM32F4xx/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../Lib/CMSIS/CM4/: startup_stm32f407xx.s
  group Lua
    ../lua/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lua.c lundump.c lutf8lib.c lvm.c lzio.c
  group modules
    ../modules/cm4/: module_adc.c module_comm.c module_flash.c module_gpio.c module_key.c module_led.c xmodem.c module_sht1.c
  group LibUSB
    ../Lib/VCP/USBDevLib/: usbd_cdc_core_loopback.c usbd_core.c usbd_ioreq.c usbd_req.c
    ../Lib/VCP/USBOTGD/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../Lib/VCP/src/: stm32fxxx_USB_it.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group spifs
    ../spiffs/: spiffs_cache.c spiffs_check.c spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c spiflash.c
